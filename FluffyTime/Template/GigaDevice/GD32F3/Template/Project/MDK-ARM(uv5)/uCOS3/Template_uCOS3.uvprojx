# Keil uVision project Template_uCOS3.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F10X_HD
  c include: ..\..\..\Libraries\CMSIS_5\Include;..\..\..\Libraries\GD32F30x\Include;..\..\..\Libraries\GD32F30x_standard_peripheral\Include;..\..\..\Source\Applications\Include;..\..\..\Source\Components\Include;..\..\..\Source\Drivers\Include;..\..\..\Source\Public\Include;..\..\..\Source\OS\uC\uC-Cfg;..\..\..\Source\OS\uC\uC-CPU;..\..\..\Source\OS\uC\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\..\..\Source\OS\uC\uC-LIB\Source;..\..\..\Source\OS\uC\uC-OS3\Source;..\..\..\Source\OS\uC\uC-OS3\Ports\ARM-Cortex-M\ARMv7-M\ARM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Applications
    ../../../Source/Applications/Source/: main.c
  group Drivers
    ../../../Source/Drivers/Source/: systick.c console_output.c
  group Public
    ../../../Source/Public/Source/: service.c port.c
  group Libraries
    ../../../Libraries/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    ../../../Libraries/GD32F30x/Source/: system_gd32f30x.c gd32f30x_it.c
    ../../../Libraries/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group CMSIS
    ../../../Libraries/CMSIS_5/Include/: cmsis_version.h cmsis_armcc.h cmsis_compiler.h core_cm4.h mpu_armv7.h
  group uC/Cfg
    ../../../Source/OS/uC/uC-Cfg/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uC/CPU
    ../../../Source/OS/uC/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
    ../../../Source/OS/uC/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../../Source/OS/uC/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm cpu.h
  group uC/LIB
    ../../../Source/OS/uC/uC-LIB/Source/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS3 Source
    ../../../Source/OS/uC/uC-OS3/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS3 Port
    ../../../Source/OS/uC/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../../Source/OS/uC/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu.h os_cpu_a.asm
